agl-ivi-demo-platform.bbappend