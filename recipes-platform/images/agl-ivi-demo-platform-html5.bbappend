IMAGE_INSTALL:append = " \
    psplash \
"
