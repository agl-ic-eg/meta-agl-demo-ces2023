agl-ivi-demo-platform-html5.bbappend